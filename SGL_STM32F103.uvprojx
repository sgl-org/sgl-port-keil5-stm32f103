# Keil uVision project SGL_STM32F103.uvprojx, settings and files
target SGL_STM32F103 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SGL_STM32F103
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\sgl;.\sgl\include;.\user\lib\cmsis;.\user\hal\STM32F10x_StdPeriph_Driver\inc;.\user\hal\STM32F10x_StdPeriph_Driver;.\user\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group sgl
    ./sgl/core/: sgl_anim.c sgl_core.c sgl_event.c sgl_log.c sgl_math.c sgl_misc.c
    ./sgl/draw/: sgl_draw_arc.c sgl_draw_bar.c sgl_draw_circle.c sgl_draw_icon.c sgl_draw_line.c sgl_draw_pie.c sgl_draw_rect.c sgl_draw_ring.c sgl_draw_text.c
    ./sgl/fonts/: sgl_ascii_consolas23.c sgl_ascii_kai33.c sgl_ascii_song23.c
    ./sgl/mm/lwmem/: lwmem.c sgl_mm.c
    ./sgl/widgets/button/: sgl_button.c
    ./sgl/widgets/arc/: sgl_arc.c
    ./sgl/widgets/checkbox/: sgl_checkbox.c
    ./sgl/widgets/circle/: sgl_circle.c
    ./sgl/widgets/icon/: sgl_icon.c
    ./sgl/widgets/label/: sgl_label.c
    ./sgl/widgets/line/: sgl_line.c
    ./sgl/widgets/listview/: sgl_listview.c
    ./sgl/widgets/msgbox/: sgl_msgbox.c
    ./sgl/widgets/rectangle/: sgl_rectangle.c
    ./sgl/widgets/ring/: sgl_ring.c
    ./sgl/widgets/slider/: sgl_slider.c
    ./sgl/widgets/switch/: sgl_switch.c
    ./sgl/widgets/textbox/: sgl_textbox.c
    ./sgl/widgets/textline/: sgl_textline.c
    ./sgl/widgets/keyboard/: sgl_keyboard.c
  group user
    ./user/src/: hongbao.c main.c stm32f10x_it.c tft.c
    ./user/hal/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
